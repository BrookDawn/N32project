# Keil uVision project FreeRTOS_N32L40X_TEM.uvprojx, settings and files
target N32L403KBQ7 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32L403KB Nationstech
  pack: Nationstech.N32L40x_DFP.0.1.0
  cpu: IRAM(0x20000000,0x6000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FreeRTOS_N32L40X_TEM
  AfterMake: fromelf --bin --output=.\Objects\FreeRTOS_N32L40X_TEM.bin .\Objects\FreeRTOS_N32L40X_TEM.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32L40X,USE_STDPRERIPH_DRIVER
  c include: .\firmware\CMSIS\core;.\firmware\CMSIS\device\startup;.\firmware\CMSIS\device;.\firmware\n32l40x_std_periph_driver\inc;.\RTOS\inc;.\RTOS\port;.\RTOS\src;.\USER\inc;.\USER\src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group SRARUP
    ./firmware/CMSIS/device/startup/: startup_n32l40x.s
  group FWLIB
    ./firmware/n32l40x_std_periph_driver/src/: misc.c n32l40x_adc.c n32l40x_can.c n32l40x_comp.c n32l40x_crc.c n32l40x_dac.c n32l40x_dbg.c n32l40x_dma.c n32l40x_exti.c n32l40x_flash.c n32l40x_gpio.c n32l40x_i2c.c n32l40x_iwdg.c n32l40x_lcd.c n32l40x_lptim.c n32l40x_lpuart.c n32l40x_opamp.c n32l40x_pwr.c n32l40x_rcc.c n32l40x_rtc.c n32l40x_spi.c n32l40x_tim.c n32l40x_usart.c n32l40x_wwdg.c
  group CMSIS
    ./firmware/CMSIS/device/: system_n32l40x.c
  group USER
    ./USER/src/: main.c n32l40x_it.c
  group RTOS_CORE
    ./RTOS/src/: croutine.c event_groups.c FreeRTOSConfig.h list.c queue.c stream_buffer.c tasks.c timers.c
  group RTOS_PORT
    ./RTOS/port/: heap_4.c port.c
    ./RTOS/inc/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group README
    ./: README.en.md README.md
