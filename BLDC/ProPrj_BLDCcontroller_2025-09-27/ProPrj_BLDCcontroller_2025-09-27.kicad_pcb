# Repository BrookDawn/N32project

File README.md:

# N32project

基于 **Nations N32G430 微控制器** (ARM Cortex-M4) 的嵌入式开发项目，包含固件开发和硬件设计。

## 目录结构

```
N32project/
├── BLDC/                      # BLDC电机控制器硬件设计 (KiCad)
├── Light_bicycle/             # 自行车灯硬件设计 (KiCad)
└── N32G430_HEX/               # N32G430主项目
    ├── Hardware/              # 开发板硬件设计
    └── Software/              # 软件项目
        ├── N32G430_gcc_buffer/          # Modbus主从机项目
        ├── N32G430_gcc_buffer_rtthread/ # RT-Thread集成版本
        ├── N32G430_gcc_example/         # OLED驱动示例
        ├── N32G430_gcc_example_oled/    # OLED多屏幕适配
        └── N32G430_g++/                 # C++版本 (LED抽象层)
```

## 主要功能模块

### Modbus RTU 协议栈

完整的 Modbus RTU 主从机实现：

**从机功能** (`modbus_slave.c`):
- 功能码: 0x01/0x02 (读线圈/离散输入), 0x03/0x04 (读保持/输入寄存器), 0x05/0x06 (写单个线圈/寄存器), 0x0F/0x10 (写多个线圈/寄存器)
- 256个保持寄存器, 64个输入寄存器, 64个线圈, 64个离散输入
- USART1 DMA中断通信
- CRC16校验和异常码响应

**主机功能** (`modbus_master.c`):
- 寄存器轮询读取和写请求队列
- 支持功能码 0x03, 0x06, 0x10
- USART2 DMA通信

**全局变量表** (`modbus_vars.c`):
- 预定义变量索引 (系统参数、PID参数、模拟量等)
- EEPROM保存支持

### OLED 显示驱动

- 多屏幕支持: SSD1306 (0.96", 0.91"), SH1106 (1.3")
- 分辨率: 128x64, 128x32
- I2C DMA传输
- U8G2风格绘图API
- 分区刷新 (脏矩形跟踪)
- 动画系统和UI组件

### LED 控制系统 (C++)

- 分层架构: 应用层 -> 抽象层 -> 适配层 -> BSP -> 硬件
- 状态管理和闪烁控制
- 平台无关设计

## 技术栈

| 类别 | 技术 |
|------|------|
| MCU | Nations N32G430 (ARM Cortex-M4, 128MHz, FPU) |
| 编译器 | ARM GCC (arm-none-eabi-gcc) |
| 调试器 | J-Link + SEGGER RTT |
| PCB设计 | KiCad |
| 通信协议 | Modbus RTU, I2C, USART (DMA) |
| 操作系统 | 裸机 / RT-Thread (可选) |

## 构建方法

```bash
cd N32G430_HEX/Software/N32G430_gcc_buffer
make          # 编译
make flash    # 下载到开发板
make clean    # 清理
```

编译配置:
- CPU: Cortex-M4
- FPU: fpv4-sp-d16 (硬件浮点)
- 优化: -Os

## 测试

Python测试脚本位于 `test/` 目录:

```bash
python test/modbus_slave_test.py   # Modbus从机测试
python test/modbus_vars_test.py    # 变量表测试
python test/serial_test.py         # 串口测试
```

## 硬件项目

| 项目 | 说明 |
|------|------|
| BLDC电机控制器 | 无刷直流电机驱动板 |
| 自行车灯控制器 | 基于N32G430CBT7 |
| N32G430开发板 | 含Gerber制造文件 |

## 许可证

本项目仅供学习和参考使用。

## KiCad design BLDC/ProPrj_BLDCcontroller_2025-09-27/ProPrj_BLDCcontroller_2025-09-27.kicad_pcb

Parts:
C1, C4, C5, C6, C9, C10, C14, C18, C20, C21, C23: 100nF; R_0603_1608Metric
C2, C17: 10uF; R_0603_1608Metric
C3, C7, C8, C22: 1uF; R_0603_1608Metric
C11, C12: 22uF; R_0603_1608Metric
C13: 75pF; R_0603_1608Metric
C15, C16: 15pF; C_0603_1608Metric; Voltage 50V; Tolerance 5%
C19: 10nF; C_0603_1608Metric
C24: 0.1uF; C_0603_1608Metric; Voltage 25V; Tolerance 20%
CN1: WAFER-GH1.25-7PLB; CONN-SMD_7P-P1.25_XUNPU_WAFER-GH1.25-7PLB; Manufacturer Part WAFER-GH1.25-7PLB; LCSC Part Name 1x7P 间距:1.25mm 立贴 系列:GH
J1, J2, J3, J4, J5: Conn_01x01; SolderWirePad_1x01_SMD_1x2mm
R1: 5.1K; R_0603_1608Metric
R2: 511K; R_0603_1608Metric
R3: 105K; R_0603_1608Metric
R4: 49.9; R_0603_1608Metric
R5: 100K; R_0603_1608Metric
R6: 13.3K; R_0603_1608Metric
R7: 0; R_0603_1608Metric
R8: 10k; R_0603_1608Metric
R9: 1K; R_0603_1608Metric
R10, R11: 10K; R_0603_1608Metric
SW2: SMD_4.2x3.2mm_h2.5mm; Push_SMD_4.2x3.2mm
U1: SGM2019-3.3YN5G/TR; SOT-23-5; Manufacturer Part SGM2019-3.3YN5G/TR; LCSC Part Name JSM2019-3.3YN5G/TR
U2: TPS54302DDCR; SOT-23-6; Manufacturer Part TPS54302DDCR; LCSC Part Name 4.5V至28V输入、3A输出、EMI友好的同步降压转换器
U3: N32G430C8L7; Manufacturer Part N32G430C8L7; LCSC Part Name N32G430C8L7
U4: 10uH; L_Changjiang_FTC252012S; Manufacturer Part XR0420-4R7M; LCSC Part Name 4.7uH ±20% 3A
U5: DRV8313PWPR; HTSSOP-28-1EP_4.4x9.7mm_P0.65mm_EP2.75x6.2mm; Manufacturer Part DRV8313PWPR; LCSC Part Name 无刷直流BLDC电机驱动芯片 60V
U6, U7: INA199A1DCKR; SC-70-6_L2.2-W1.3-P0.65-LS2.1-BR; Manufacturer Part INA199A1DCKR; LCSC Part Name INA199A1DCKR
U8, U9: 1mΩ; R1206; Manufacturer Part FRM121WFR001TM; LCSC Part Name 1mΩ ±1% 1W
U10: AS5600-ASOM; SOIC-8_3.9x4.9mm_P1.27mm; Manufacturer Part AS5600-ASOM; LCSC Part Name AS5600-ASOM
Y1: 12MHz; Crystal_SMD_2.5x2.0mm

Connections:
3.3V: C1.2, C4.2, C6.2, C7.2, C8.2, C10.2, C14.2, C22.2, C23.2, CN1.7, R10.1, R11.2, U1.5 (OUT), U3.1 (VDD), U3.9 (VDDA), U3.24 (VDD), U3.48 (VDD), U6.3 (V+), U7.3 (V+), U10.1 (VDD5V), U10.2 (VDD3V3)
+5V: C3.2, C11.2, C12.2, R1.2, R4.2, U1.1 (IN), U4.2
/BOOT0: R8.1, U3.44 (PD0-BOOT0)
/EN: R2.1, R3.2, U2.5 (EN)
/MOTOR1: J3.1, U6.5 (IN-), U8.2
/MOTOR2: J4.1, U7.5 (IN-), U9.2
/NRST: C24.2, SW2.2, U3.7 (NRST)
/OSC_IN: C15.1, U3.5 (PD14-OSC_IN), Y1.1
/OSC_OUT: C16.1, U3.6 (PD15-OSC_OUT), Y1.3
/OUT1: U5.5 (OUT1), U6.4 (IN+), U8.1
/OUT2: U5.8 (OUT2), U7.4 (IN+), U9.1
/PA0: U3.10 (PA0)
/PA1: U3.11 (PA1)
/PA2: U3.12 (PA2)
/PA3: U3.13 (PA3)
/PA4: U3.14 (PA4)
/PA5: U3.15 (PA5)
/PA6: U3.16 (PA6), U5.26 (EN1)
/PA7: U3.17 (PA7), U5.24 (EN2)
/PA8: U3.29 (PA8)
/PA9: U3.30 (PA9)
/PA11: U3.32 (PA11)
/PA12: U3.33 (PA12)
/PB0: U3.18 (PB0), U5.22 (EN3)
/PB1: U3.19 (PB1)
/PB2: U3.20 (PB2)
/PB5: U3.41 (PB5)
/PB6: R10.2, U3.42 (PB6), U10.7 (SCL)
/PB7: R11.1, U3.43 (PB7), U10.6 (SDA)
/PB9: U3.46 (PB9)
/PB10: U3.21 (PB10)
/PB11: U3.22 (PB11)
/PB12: U3.25 (PB12)
/PB13: U3.26 (PB13)
/PB15: U3.28 (PB15)
/PC13: U3.2 (PC13-TAMPER-RTC)
/PC14: U3.3 (PC14-OSC32_IN)
/PC15: U3.4 (PC15-OSC32_OUT)
/PD12: U3.35 (PD12)
/PD13: U3.36 (PD13)
/PGND: R7.2, U5.6 (PGND1), U5.7 (PGND2), U5.10 (PGND3), U5.29 (EP)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C10.1, C11.1, C12.1, C14.1, C15.2, C16.2, C17.1, C18.1, C22.1, C23.1, C24.1, CN1.4, CN1.8, CN1.9, J2.1, R3.1, R6.1, R7.1, R8.2, R9.2, SW2.1, U1.2 (GND), U2.1 (GND), U3.8 (VSSA), U3.23 (VSS), U3.47 (VSS), U5.12 (COMPP), U5.13 (COMPN), U5.14 (GND), U5.20 (GND), U5.28 (GND), U6.1 (REF), U6.2 (GND), U7.1 (REF), U7.2 (GND), U10.4 (GND), U10.8 (DIR), Y1.2, Y1.4
JTCK: CN1.5, U3.37 (PA14)
JTDI: CN1.3, U3.38 (PA15)
JTDO: CN1.2, U3.39 (PB3)
JTMS: CN1.6, U3.34 (PA13)
MOTOR3: J5.1, U5.9 (OUT3)
NJTRST: CN1.1, U3.40 (PB4)
unnamed: C13.2, R4.1, R5.2
unnamed: R1.1, U1.3 (EN)
unnamed: C9.1, U2.6 (BOOT)
unnamed: C13.1, R5.1, R6.2, U2.4 (FB)
unnamed: C9.2, U2.2 (SW), U4.1
unnamed: C21.2, U5.19 (COMPO#)
unnamed: C19.2, U5.1 (CP1)
unnamed: C19.1, U5.2 (CP2)
unnamed: C21.1, U5.15 (V3P3OUT), U5.16 (RESET#), U5.17 (SLEEP#)
unnamed: C20.2, U5.3 (VCP)
unnamed: R9.1, U10.5 (PGO)
TIM1_CH1: U3.27 (PB14), U5.27 (IN1)
TIM1_CH2: U3.45 (PB8), U5.25 (IN2)
TIM1_CH3: U3.31 (PA10), U5.23 (IN3)
VCC: C2.2, C5.2, C17.2, C18.2, C20.1, J1.1, R2.2, U2.3 (VIN), U5.4 (VM), U5.11 (VM)

Notes on the sheet:
降压电路

Board: 4 copper layers, 40.0 x 40.0 mm, 53 parts (26 on the bottom side), 39 nets.

## KiCad design Light_bicycle/Hareware/light_bicycle/light_bicycle.kicad_pcb

Parts:
C1: 4.7uF; C_0603_1608Metric; Voltage 35V; Tolerance 20%
C2, C3, C5, C10, C11: 0.1uF; C_0603_1608Metric; Voltage 25V; Tolerance 20%
C4, C12, C13, C16: 1uF; C_0603_1608Metric; Voltage 25V; Tolerance 20%
C6, C7: 9pF; C_0603_1608Metric; Voltage 16V; Tolerance 10%
C8, C9: 12pF; C_0603_1608Metric; Voltage 16V; Tolerance 10%
C14, C15: 100nF; C_0603_1608Metric; Voltage 25V; Tolerance 20%
C17, C28, C30: 10uF; C_0805_2012Metric; Voltage 25V; Tolerance 10%
C18, C20, C29, C31, C32, C33: 100nF; C_0805_2012Metric; Voltage 25V; Tolerance 10%
C19: 2.2uF; C_0603_1608Metric; Voltage 10V; Tolerance 20%
C21: 47nF; C_0603_1608Metric; Voltage 10V; Tolerance 10%
C22, C23, C24: 22uF; C_0805_2012Metric; Voltage 10V; Tolerance 20%
C25: 1uF; C_0805_2012Metric; Voltage 25V; Tolerance 10%
C26: 3.3nF; C_0603_1608Metric; Voltage 35V; Tolerance 20%
C27: 10pF; C_0603_1608Metric; Voltage 50V; Tolerance 5%
C34: 10nF; C_0603_1608Metric; Voltage 25V; Tolerance 20%
D1, D3: Red; LED_0603_1608Metric_Red
D2: Blue; LED_0603_1608Metric_Blue
D4: Green; LED_0603_1608Metric_Red
J1: USART1; JST_SMD_1.25mm-3_Locking
J2: 电池; 1x02
J3, J4: SWD; 1x04
J5: USB_C_Receptacle; USB-C_16
L1: 1.5uH; Inductor_7.3x6.6mm
R1, R6, R18, R19: 5.1k; R_0603_1608Metric
R2: 0; R_0603_1608Metric
R3, R12: 100k; R_0603_1608Metric
R4, R16: 10k; R_0603_1608Metric
R5, R7: 1k; R_0603_1608Metric
R8: 220; R_0603_1608Metric
R9: 62k; R_0603_1608Metric
R10: 1.5k; R_0603_1608Metric
R11: 4.7k; R_0603_1608Metric
R13: 269k; R_0603_1608Metric
R14: 0.2R; R_1206_3216Metric
R15, R17: 2k; R_0603_1608Metric
SW1, SW2, SW3: SMD_4.2x3.2mm_h2.5mm; Push_SMD_4.2x3.2mm
TP1, TP2, TP3, TP4, TP5, TP6: 0.75mm; TestPoint-0.75mm
U1: QFP-48_8.35x8.35_Pitch0.5mm
U2: SGM2019
U3: TPS61088RHLR
U4: TP4056-42-ESOP8; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.3mm_ThermalVias
U5: MPU6500
Y1: 8MHz; Crystal_SMD_3.2x2.5mm
Y2: 32.768kHz; Crystal_SMD_3.2x1.5mm

Connections:
+5V: C22.1, C23.1, C24.1, C25.1, R11.2, TP2.1, U3.14 (VOUT), U3.15 (VOUT), U3.16 (VOUT)
/BOOT0: R4.1, SW2.2, U1.44 (PD0-BOOT0)
/NRST: C5.2, SW1.2, U1.7 (NRST)
/PA0: U1.10 (PA0)
/PA1: U1.11 (PA1)
/PA2: U1.12 (PA2)
/PA3: U1.13 (PA3)
/PA4: U1.14 (PA4)
/PA5: U1.15 (PA5)
/PA6: U1.16 (PA6)
/PA7: U1.17 (PA7)
/PA8: U1.29 (PA8)
/PA9: J1.3, U1.30 (PA9)
/PA10: J1.2, U1.31 (PA10)
/PA11: U1.32 (PA11)
/PA12: U1.33 (PA12)
/PA15: U1.38 (PA15)
/PB0: U1.18 (PB0)
/PB1: U1.19 (PB1)
/PB2: D2.2 (A), U1.20 (PB2)
/PB3: U1.39 (PB3)
/PB4: U1.40 (PB4)
/PB5: U1.41 (PB5)
/PB6: TP5.1, U1.42 (PB6), U5.23 (SCL)
/PB7: TP6.1, U1.43 (PB7), U5.24 (SDA)
/PB8: U1.45 (PB8), U5.12 (INT)
/PB9: U1.46 (PB9)
/PB10: U1.21 (PB10)
/PB11: U1.22 (PB11)
/PB12: U1.25 (PB12)
/PB13: U1.26 (PB13)
/PB14: U1.27 (PB14)
/PB15: U1.28 (PB15)
/PC13: U1.2 (PC13-TAMPER-RTC)
/PC14: C16.2, R6.2, SW3.2
/PD12: U1.35 (PD12)
/PD13: U1.36 (PD13)
DIO: J4.2, U1.34 (PA13)
unnamed: C20.2, U3.6 (SW), U3.7 (SW)
unnamed: C26.1, R9.2
unnamed: D1.2 (A), R7.2
unnamed: D2.1 (K), R8.2
unnamed: D3.2 (A), R15.2
unnamed: D3.1 (K), U4.7 (~CHRG)
unnamed: D4.2 (A), R16.2
unnamed: D4.1 (K), U4.6 (~STDBY)
unnamed: J5.A5 (CC1), R19.1
unnamed: J5.B5 (CC2), R18.1
unnamed: J5.A6 (D+), J5.B6 (D+)
unnamed: J5.A7 (D-), J5.B7 (D-)
unnamed: L1.2, R13.1, U3.4 (SW), U3.5 (SW)
unnamed: R5.1, SW2.1
unnamed: C6.1, U1.3 (PC14-OSC32_IN), Y2.2
unnamed: C7.1, U1.4 (PC15-OSC32_OUT), Y2.1
unnamed: C8.1, U1.5 (PD14-OSC_IN), Y1.1 (OSC_IN)
unnamed: C9.2, U1.6 (PD15-OSC_OUT), Y1.3 (OSC_OUT)
unnamed: R1.2, U2.3 (EN)
unnamed: C20.1, U3.8 (BOOT)
unnamed: C27.1, R9.1, U3.18 (COMP)
unnamed: R12.2, U3.2 (EN)
unnamed: R10.1, R11.1, U3.17 (FB)
unnamed: R13.2, U3.3 (FSW)
unnamed: R3.1, U3.19 (ILIM)
unnamed: C21.2, U3.10 (SS)
unnamed: C19.1, U3.1 (VCC)
unnamed: C30.1, C31.2, R14.1, R15.1, R16.1, U4.4 (V_{CC}), U4.8 (CE)
unnamed: R17.1, U4.2 (PROG)
unnamed: C33.1, U5.10 (REGOUT)
PGND: C17.2, C18.1, C22.2, C23.2, C24.2, C25.2, C28.2, C29.1, C30.2, C31.1, R2.1, R17.2, U3.20 (PGND), U4.3 (GND), U4.9 (EPAD)
SCK: J4.3, U1.37 (PA14)
VBUS: C12.2, C17.1, C18.2, C28.1, C29.2, J2.2, L1.1, R1.1, R12.1, TP3.1, U2.1 (IN), U3.9 (VIN), U4.5 (BAT)
VDD: C1.1, C2.2, C3.2, C4.2, C10.2, C11.2, C13.2, C14.2, C15.2, C32.1, C34.2, J4.1, R6.1, R7.1, TP4.1, U1.1 (VDD), U1.9 (VDDA), U1.24 (VDD), U1.48 (VDD), U2.5 (OUT), U5.8 (VDDIO), U5.13 (VDD), U5.22 (nCS)
VSS: C1.2, C2.1, C3.1, C4.1, C5.1, C6.2, C7.2, C8.2, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C19.2, C21.1, C26.2, C27.2, C32.2, C33.2, C34.1, D1.1 (K), J1.1, J2.1, J4.4, J5.GND, J5.S (SHIELD), R2.2, R3.2, R4.2, R8.1, R10.2, R18.2, R19.2, SW1.1, SW3.1, U1.8 (VSSA), U1.23 (VSS), U1.47 (VSS), U2.2 (GND), U3.21 (AGND), U4.1 (TEMP), U5.18 (GND), U5.20 (RESV), U5.25 (EP), Y1.2, Y1.4

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
Board: 2 copper layers, 79 parts (0 on the bottom side), 48 nets, no tracks yet.

## KiCad design N32G430_HEX/Hardware/N32G430/Kicad/N32G430_HEX/N32G430_HEX.kicad_pcb

Parts:
C1: 4.7uF; C_0603_1608Metric; Voltage 35V; Tolerance 20%
C2, C3, C5, C10, C11: 0.1uF; C_0603_1608Metric; Voltage 25V; Tolerance 20%
C4, C12, C13, C16: 1uF; C_0603_1608Metric; Voltage 25V; Tolerance 20%
C6, C7: 9pF; C_0603_1608Metric; Voltage 16V; Tolerance 10%
C8, C9: 12pF; C_0603_1608Metric; Voltage 16V; Tolerance 10%
C14, C15: 100nF; C_0603_1608Metric; Voltage 25V; Tolerance 20%
D1: Red; LED_0603_1608Metric_Red
D2: Blue; LED_0603_1608Metric_Blue
J1: USB_C_Receptacle; USB-C_16
J2, J3: Conn_01x20; 1x20
J4: Conn_01x04; 1x04
R1, R2, R3, R6: 5.1k; R_0603_1608Metric
R4: 10k; R_0603_1608Metric
R5, R7, R8: 1k; R_0603_1608Metric
SW1, SW2, SW3: SMD_4.2x3.2mm_h2.5mm; Push_SMD_4.2x3.2mm
U1: QFP-48_8.35x8.35_Pitch0.5mm
U2: SGM2019
Y1: 8MHz; Crystal_SMD_3.2x2.5mm
Y2: 32.768kHz; Crystal_SMD_3.2x1.5mm

Connections:
5V: C12.2, J1.VBUS, J2.1, J3.3, R1.1, R5.2, U2.1 (IN)
/BOOT0: R4.1, SW2.2, U1.44 (PD0-BOOT0)
/NRST: C5.2, J2.4, SW1.2, U1.7 (NRST)
/PA0: J2.16, U1.10 (PA0)
/PA1: J2.15, U1.11 (PA1)
/PA2: J2.14, U1.12 (PA2)
/PA3: J2.13, U1.13 (PA3)
/PA4: J2.12, U1.14 (PA4)
/PA5: J2.11, U1.15 (PA5)
/PA6: J2.10, U1.16 (PA6)
/PA7: J2.9, U1.17 (PA7)
/PA8: J3.16, U1.29 (PA8)
/PA9: J3.15, U1.30 (PA9)
/PA10: J3.14, U1.31 (PA10)
/PA11: J3.13, U1.32 (PA11)
/PA12: J3.12, U1.33 (PA12)
/PA15: J3.11, U1.38 (PA15)
/PB0: J2.8, U1.18 (PB0)
/PB1: J2.7, U1.19 (PB1)
/PB2: D2.1 (K), U1.20 (PB2)
/PB3: J3.10, U1.39 (PB3)
/PB4: J3.9, U1.40 (PB4)
/PB5: J3.8, U1.41 (PB5)
/PB6: J3.7, U1.42 (PB6)
/PB7: J3.6, U1.43 (PB7)
/PB8: J3.5, U1.45 (PB8)
/PB9: J3.4, U1.46 (PB9)
/PB10: J2.6, U1.21 (PB10)
/PB11: J2.5, U1.22 (PB11)
/PB12: J3.20, U1.25 (PB12)
/PB13: J3.19, U1.26 (PB13)
/PB14: J3.18, U1.27 (PB14)
/PB15: J3.17, U1.28 (PB15)
/PC13: J2.19, U1.2 (PC13-TAMPER-RTC)
/PC14: C16.2, J2.18, R6.2, SW3.2
/PC15: J2.17
/PD12: U1.35 (PD12)
/PD13: U1.36 (PD13)
DIO: J4.2, U1.34 (PA13)
unnamed: D1.2 (A), R7.2
unnamed: D2.2 (A), R8.2
unnamed: J1.A5 (CC1), R2.1
unnamed: J1.B5 (CC2), R3.1
unnamed: J1.A6 (D+), J1.B6 (D+)
unnamed: J1.A7 (D-), J1.B7 (D-)
unnamed: R5.1, SW2.1
unnamed: C6.1, U1.3 (PC14-OSC32_IN), Y2.2
unnamed: C7.1, U1.4 (PC15-OSC32_OUT), Y2.1
unnamed: C8.1, U1.5 (PD14-OSC_IN), Y1.1 (OSC_IN)
unnamed: C9.2, U1.6 (PD15-OSC_OUT), Y1.3 (OSC_OUT)
unnamed: R1.2, U2.3 (EN)
SCK: J4.3, U1.37 (PA14)
VDD: C1.1, C2.2, C3.2, C4.2, C10.2, C11.2, C13.2, C14.2, C15.2, J2.3, J2.20, J3.1, J4.1, R6.1, R7.1, R8.1, U1.1 (VDD), U1.9 (VDDA), U1.24 (VDD), U1.48 (VDD), U2.5 (OUT)
VSS: C1.2, C2.1, C3.1, C4.1, C5.1, C6.2, C7.2, C8.2, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, D1.1 (K), J1.GND, J1.S (SHIELD), J2.2, J3.2, J4.4, R2.2, R3.2, R4.2, SW1.1, SW3.1, U1.8 (VSSA), U1.23 (VSS), U1.47 (VSS), U2.2 (GND), Y1.2, Y1.4

Board: 2 copper layers, 52.8 x 20.8 mm, 37 parts (12 on the bottom side), 51 nets.

## Code that names these connections

File N32G430_HEX/Software/N32G430_gcc_example_oled/core/inc/display_config.h:

/**
 * @file display_config.h
 * @brief 显示设备配置 - 选择SPI1驱动OLED或LCD
 */

#ifndef DISPLAY_CONFIG_H
#define DISPLAY_CONFIG_H

#ifdef __cplusplus
extern "C" {
#endif

/**
 * @brief 显示设备类型选择
 *
 * 通过定义以下宏来选择SPI1驱动的显示设备：
 *
 * DISPLAY_USE_OLED - 使用OLED显示屏 (SSD1306/SH1106)
 * DISPLAY_USE_LCD  - 使用LCD显示屏 (ST7735S)
 *
 * 默认使用OLED，如需使用LCD，请在编译时定义 DISPLAY_USE_LCD
 * 或在包含此头文件前定义
 */

// #define DISPLAY_USE_OLED
// #define DISPLAY_USE_LCD
 
/* 显示设备类型枚举 */
typedef enum {
    DISPLAY_TYPE_OLED = 0,
    DISPLAY_TYPE_LCD
} DisplayType_t;

/* 默认配置 - 如果两个都没定义，默认使用OLED */
#if !defined(DISPLAY_USE_OLED) && !defined(DISPLAY_USE_LCD)
#define DISPLAY_USE_OLED
#endif

/* 确保只能选择一种设备 */
#if defined(DISPLAY_USE_OLED) && defined(DISPLAY_USE_LCD)
#error "Cannot use both OLED and LCD at the same time. Please define only one."
#endif

/* 引脚配置 */

/* 公共引脚 (SPI1) */
/* SCK:  PA5 (AF1) */
/* MOSI: PA7 (AF1) */
/* RES:  PA6 (GPIO) */
/* DC:   PB0 (GPIO) */
/* CS:   PB1 (GPIO) */

/* LCD特有引脚 */
/* BL:   PB10 (GPIO) - 仅LCD使用背光控制 */

#ifdef DISPLAY_USE_LCD
#define DISPLAY_HAS_BACKLIGHT   1
#else
#define DISPLAY_HAS_BACKLIGHT   0
#endif

#ifdef __cplusplus
}
#endif

#endif /* DISPLAY_CONFIG_H */

File N32G430_HEX/Software/N32G430_gcc_buffer/core/src/bsp_usart.c (part):

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    RCC_AHB_Peripheral_Clock_Enable(USART1_GPIO_CLK);
    RCC_APB2_Peripheral_Clock_Enable(USART1_CLK);

    /* 配置USART1 TX引脚 (PA9) */
    GPIO_InitStructure.Pin              = USART1_TX_PIN;
    GPIO_InitStructure.GPIO_Mode        = GPIO_MODE_AF_PP;
    GPIO_InitStructure.GPIO_Pull        = GPIO_NO_PULL;
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    GPIO_InitStructure.GPIO_Alternate   = GPIO_AF5_USART1;
    GPIO_Peripheral_Initialize(USART1_GPIO_PORT, &GPIO_InitStructure);

    /* 配置USART1 RX引脚 (PA10) */
    GPIO_InitStructure.Pin              = USART1_RX_PIN;
    GPIO_InitStructure.GPIO_Mode        = GPIO_MODE_INPUT;
    GPIO_InitStructure.GPIO_Pull        = GPIO_NO_PULL;
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    RCC_AHB_Peripheral_Clock_Enable(USART2_GPIO_CLK | RCC_AHB_PERIPH_DMA);
    RCC_APB1_Peripheral_Clock_Enable(USART2_CLK);

    /* TX: PA2 */
    GPIO_InitStructure.Pin              = USART2_TX_PIN;
    GPIO_InitStructure.GPIO_Mode        = GPIO_MODE_AF_PP;
    GPIO_InitStructure.GPIO_Pull        = GPIO_NO_PULL;
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    GPIO_InitStructure.GPIO_Alternate   = USART2_GPIO_AF;
    GPIO_Peripheral_Initialize(USART2_GPIO_PORT, &GPIO_InitStructure);

    /* RX: PA3 */
    GPIO_InitStructure.Pin              = USART2_RX_PIN;
    GPIO_InitStructure.GPIO_Mode        = GPIO_MODE_INPUT;
    GPIO_InitStructure.GPIO_Pull        = GPIO_NO_PULL;
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    RCC_AHB_Peripheral_Clock_Enable(USART1_GPIO_CLK | RCC_AHB_PERIPH_DMA);
    RCC_APB2_Peripheral_Clock_Enable(USART1_CLK);

    /* TX: PA9 */
    GPIO_InitStructure.Pin              = USART1_TX_PIN;
    GPIO_InitStructure.GPIO_Mode        = GPIO_MODE_AF_PP;
    GPIO_InitStructure.GPIO_Pull        = GPIO_NO_PULL;
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    GPIO_InitStructure.GPIO_Alternate   = GPIO_AF5_USART1;
    GPIO_Peripheral_Initialize(USART1_GPIO_PORT, &GPIO_InitStructure);

    /* RX: PA10 */
    GPIO_InitStructure.Pin              = USART1_RX_PIN;
    GPIO_InitStructure.GPIO_Mode        = GPIO_MODE_INPUT;
    GPIO_InitStructure.GPIO_Pull        = GPIO_NO_PULL;
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
## Commit log (part)

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2025-06-11 N32G430核心板工程及gcc工程文件
2025-06-11 添加了FreeRTOS的工程框架
2025-06-15 N32G430核心板绘制
2025-06-22 6_22
2025-07-06 gcc example
2025-07-11 Light bicycle
2025-08-07 RingBuffer Init 0807
2025-08-10 RTT 调试
2025-09-18 添加了g++ 支持的工程模板
2025-09-27 添加了BLDC controller
2025-09-29 采样电阻位置调整
2025-10-01 BLDC 更新
2025-12-08 oled driver
2025-12-09 添加 USART2 驱动和 Modbus 主站功能
2025-12-09 完善modbus主机发送，使用串口DMA中断代替阻塞收发
2025-12-09 Add Modbus write functionality and create test scripts for USART2
    - Implemented ModbusMaster_WriteSingleRegister and ModbusMaster_WriteMultipleRegisters in main.c to allow writing to registers.
    - Added a PowerShell script (test_serial.ps1) to simulate a Modbus slave for testing USART2 DMA functionality, including CRC calculation and response generation for read and write requests.
    - Created a Python script (test_serial.py) for the same purpose, ensuring compatibility with different environments and providing an alternative testing method.
2025-12-09 添加 Modbus RTU 从机协议实现及相关功能
2025-12-10 modbus从机程序及测试
2025-12-10 添加 Modbus 全局变量表的头文件和实现文件，以及相应的测试脚本
2025-12-11 添加 README.md 文件
2025-12-11 添加RTThread nano
2025-12-12 添加了SPI DMA 的OLED驱动，调整了OLED驱动的分层结构，使用同一套APP
2025-12-13 Add button input capture with DMA debouncing and display configuration
    - Implemented button input capture functionality with DMA for debouncing.
    - Added button.h and button.c files for button handling logic.
    - Introduced display_config.h for selecting between OLED and LCD display types.
    - Created documentation for button test demo, detailing functionality, configuration parameters, and testing instructions.
2025-12-14 display
2025-12-14 u8g2
2025-12-21 feat: Add Elab LED control module and USART adapter for N32G430
    - Implemented elab_led.h and elab_led.c for LED control functions including initialization, on, off, toggle, and blink.
    - Created bsp_elab_adapter.h and bsp_elab_adapter.c to adapt Elab framework for USART communication.
    - Updated ELAB_README.md with project overview, structure, functionalities, usage examples, and compilation instructions.
    - Enhanced logging capabilities with Elab framework integration.
    - Fixed LED driving logic for correct operation.
2025-12-24 Linux of_match 框架

Notices in the files:
N32G430_HEX/Software/N32G430_gcc_buffer/core/src/bsp_usart.c:
@copyright Copyright (c) 2025
